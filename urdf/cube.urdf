Commit message: Modified cubes dimension

File: urdf/cube.urdf (robot description, URDF)
Before this commit: robot simple_cube, 1 links, 0 joints
Links:
- link cube: mass 1.0 -> 0.1
